# Keil uVision project AsciiConversion.uvproj, settings and files
target LPC2468 Ext SDRAM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC2468 NXP
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: AsciiConversion
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  asm define: NO_CLOCK_SETUP NO_EMC_SETUP RAM_INTVEC RAM_MODE REMAP
  library: MicroLIB
  memory RVCT1: ROM 0xa0000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa1000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x17fc0
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Assembly Code
    ./: AsciiConversion.s
  group Libraries
    ../libcs1021/: libcs1021.lib
